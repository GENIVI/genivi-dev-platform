BRANCH ?= "maintain/2.1.6"
TAG ?= "${PV}"
SRC_URI = "git://git.projects.genivi.org/ipc/common-api-runtime.git;branch=${BRANCH};tag=${TAG}"
