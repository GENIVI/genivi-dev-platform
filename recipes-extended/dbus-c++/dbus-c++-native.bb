require dbus-c++.inc
inherit native

DEPENDS = "dbus-native expat-native"
