DEPENDS_remove = "bluez4"
DEPENDS_append = " bluez5"
