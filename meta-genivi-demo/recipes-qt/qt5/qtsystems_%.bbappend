DEPENDS_remove = "bluez4"
# currently Qt5 does not support bluez5 "Nothing PROVIDES 'gconfbluez5'"
#DEPENDS_append = "bluez5"
