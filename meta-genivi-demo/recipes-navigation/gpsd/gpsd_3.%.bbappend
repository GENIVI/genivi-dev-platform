PACKAGECONFIG[bluez] = "bluez='true',bluez='false',bluez5"
