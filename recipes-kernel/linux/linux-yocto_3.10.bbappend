COMPATIBLE_MACHINE = "koelsch"

KERNEL_ENABLE_CGROUPS = "1"
