PACKAGECONFIG = "gstreamer010 qtlocation qtmultimedia qtsensors"
