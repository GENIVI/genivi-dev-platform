FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-a2dp_source_player_adapter-fix-API-reference-to-GetD.patch"
