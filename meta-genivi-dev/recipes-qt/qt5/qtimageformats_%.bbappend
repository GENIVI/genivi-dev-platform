PACKAGECONFIG_append_dragonboard-410c = " libwebp"
