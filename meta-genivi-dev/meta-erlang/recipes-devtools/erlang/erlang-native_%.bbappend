DEPENDS_append = " ncurses-native openssl-native"
