PACKAGECONFIG = "gstreamer qtlocation qtmultimedia qtsensors"
