FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"

SRC_URI += "\ 
    file://CVE-2016-0754.patch \
    file://CVE-2016-0755.patch \
"
