# Default is "/opt/${PN}
IOTIVITY_BIN_DIR = "/usr/share/${PN}"
