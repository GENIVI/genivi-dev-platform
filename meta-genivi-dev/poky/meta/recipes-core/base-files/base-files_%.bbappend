do_configure_append() {
       echo "\033[9;0]" >> ${WORKDIR}/issue
}

dirs755 += " /Data/mnt-c /Data/mnt-wt"
