RDEPENDS_${PN}_remove = "nativesdk-dnf"

