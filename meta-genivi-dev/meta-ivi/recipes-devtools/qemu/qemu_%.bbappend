EXTRA_OECONF_remove_class-nativesdk = "--audio-drv-list=pa"
