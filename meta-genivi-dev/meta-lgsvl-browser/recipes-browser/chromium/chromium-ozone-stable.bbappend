GN_ARGS += "is_cfi=false"

